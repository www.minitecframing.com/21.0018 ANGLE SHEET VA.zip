# Autodesk Inventor assembly: 21.0018 ANGLE SHEET VA
## iProperties
Created: 2012-11
Part Number: 21.0018 ANGLE SHEET VA
Document SubType Name: Assembly
Designer: Administrator
Author: Administrator
